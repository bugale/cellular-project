# Keil uVision project Cellular.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RB2 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0 - 0xFF) CLOCK(60000000) MODP2
  output: Cellular +hex
  c flags: Optimize=9 SizeSpeed=1
  group Header Files
    ./Header Files/: Timers.h Ports.h LedsInterface.h ModemInterface.h ErrorHandler.h
  group Source Files
    ./Source Files/: Timers.c Ports.c LedsInterface.c ModemInterface.c ErrorHandler.c
  group Common Files
    ./: CommonHeader.h main.c STARTUP.A51
